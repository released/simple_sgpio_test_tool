# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.7
  cpu: IRAM(0x20000000,0x17FC0) IROM(0x00010000,0x70000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: Template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.raw.bin"
  AfterMake: generateChecksum.bat
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 v6Lto=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M261\Include;..\..\..\Library\StdDriver\inc;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x17fc0
  link misc: --map --first='startup_M261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M261/Source/: system_M261.c
    ../../../Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
  group User
    ../: main.c misc_config.c timer_service.c descriptors.c hid_transfer.c hid_tool_api.c m261_bridge_sgpio.c m261_bridge_sgpio_monitor.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c clk.c fmc.c uart.c sys.c timer.c gpio.c pdma.c usbd.c
