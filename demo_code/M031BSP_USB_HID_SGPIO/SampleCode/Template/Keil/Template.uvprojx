# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20003FBF) IROM(0x4000-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.raw.bin"
  AfterMake: generateChecksum.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 v6Lto=1
  c include: ..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x1C000
  memory RVCT9: RAM 0x20000000 size 0x3FC0
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c clk.c gpio.c fmc.c pdma.c timer.c sys.c usbd.c
  group User
    ../: main.c misc_config.c timer_service.c descriptors.c hid_transfer.c hid_tool_api.c m031_bridge_sgpio.c m031_bridge_sgpio_monitor.c
